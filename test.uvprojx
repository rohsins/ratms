# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: EFM32G232F128 Silicon Labs
  pack: Keil.EFM32Gxxx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: test.c ratms.cpp
software components: CMSIS:CORE 5.0.0, CMSIS:RTOS:Keil RTX 4.81.0, Device:Startup 4.2.1, Device:emlib:CMU 4.2.1, Device:emlib:EMU 4.2.1, Device:emlib:Framework 4.2.1, Device:emlib:GPIO 4.2.1, Device:emlib:SYSTEM 4.2.1, Device:emlib:USART 4.2.1
